SRC_URI += "file://user_2018-11-19-10-24-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

